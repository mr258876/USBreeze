# Keil uVision project Project Fan.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VirtualCOM +hex
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --entry=Reset_Handler --info summarysizes --load_addr_map_info --summary_stderr
  group Src
    ./Src/: main.c USBD_User_CDC_ACM_0.c bsp.c stm32f10x_it.c FanControl.c FanControlHostCommWrapper.c USBD_User_HID_0.c HostCommunication.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0, USB:CORE 6.15.0, USB:Device 6.15.0, USB:Device:CDC 6.15.0, CMSIS Driver:USB Device 2.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0
